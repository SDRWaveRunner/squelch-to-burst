<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>squelch_to_burst</value></param>
<param><key>author</key><value>SDRWaveRunner</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>alfa</value></param>
<param><key>value</key><value>1e-4</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>.00001</value></param>
<param><key>stop</key><value>.01</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>ampl</value></param>
<param><key>value</key><value>.1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>.005</value></param>
<param><key>stop</key><value>.2</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>grens</value></param>
<param><key>value</key><value>-20</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-80</value></param>
<param><key>step</key><value>5</value></param>
<param><key>stop</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>48000</value></param>
</block>
<block>
<key>analog_pwr_squelch_xx</key>
<param><key>id</key><value>analog_pwr_squelch_xx_0</value></param>
<param><key>alpha</key><value>alfa</value></param>
<param><key>gate</key><value>False</value></param>
<param><key>ramp</key><value>(samp_rate/10)</value></param>
<param><key>threshold</key><value>grens</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>audio_source</key>
<param><key>id</key><value>audio_source_0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_tag_debug</key>
<param><key>id</key><value>blocks_tag_debug_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_tagged_file_sink</key>
<param><key>id</key><value>blocks_tagged_file_sink_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>blocks_tags_strobe</key>
<param><key>id</key><value>blocks_tags_strobe_0</value></param>
<param><key>key</key><value>pmt.intern("strobe")</value></param>
<param><key>nsamps</key><value>int(2*samp_rate)</value></param>
<param><key>type</key><value>float</value></param>
<param><key>value</key><value>pmt.intern("TEST")</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>epy_block_0</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each time this file is saved, GRC will instantiate the first class it finds
to get ports and parameters of your block. The arguments to __init__  will
be the parameters. All of them are required to have default values!
"""

from gnuradio import gr
import numpy as np
import pmt



class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
    """
    This block blocks all the tags and translates squelch-tags to burst. 
    This is done as a 2-to-1 translation:
    "squelch_sob" gets replaced with "burst" True
    and
    "squelch_eob" gets replaced with "burst" False
    """

    def __init__(self):
        """arguments to this function show up as parameters in GRC"""
        gr.sync_block.__init__(
            self,
            name='Squelch to Burst',   # will show up in GRC
            in_sig=[np.float32],
            out_sig=[np.float32]
        )
        self.squelch_state = False
        # Modify the tag-propagation-policy so inbound tags are not propagated
        self.set_tag_propagation_policy(gr.TPP_DONT)

    def work(self, input_items, output_items):
        for indx, sample in enumerate(input_items[0]):
            tags = self.get_tags_in_window(0, indx, len(input_items[0]))
            for tag in tags:
                key = pmt.to_python(tag.key) # convert from PMT to python string
                value = pmt.to_python(tag.value) # Note that the type(value) can be several things, it depends what PMT type it was
 
                if key == "squelch_sob" and not self.squelch_state:
                
                    self.add_item_tag(0, 
                        self.nitems_written(0) + indx,
                        pmt.intern("burst"), 
                        pmt.PMT_T ) # was: value)
                        
                    self.squelch_state = True
                
                if key == "squelch_eob" and self.squelch_state:
                    
                    self.add_item_tag(0,
                        self.nitems_written(0) + indx,
                        pmt.intern("burst"),
                        pmt.PMT_F )
                    
                    self.squelch_state = False
    
        output_items[0][:] = input_items[0]
        return len(input_items[0])
</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>comment</key><value>Lots of reading:
https://wiki.gnuradio.org/index.php/Guided_Tutorial_Programming_Topics
and
https://wiki.gnuradio.org/index.php/Guided_Tutorial_GNU_Radio_in_Python

Inspect the stream for tags, find the right one and add a tag.
Can't find a way to delete a tag:
https://www.gnuradio.org/doc/doxygen/page_stream_tags.html#stream_tags_api

The translation is a 2-to-1 translation:
squelch_sob -&gt; burst True
squelch_eob -&gt; burst False</value></param>
<param><key>note</key><value>Sources</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>"Time Sink"</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<connection><source_block_id>analog_pwr_squelch_xx_0</source_block_id><sink_block_id>epy_block_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>audio_source_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>analog_pwr_squelch_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tags_strobe_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>epy_block_0</source_block_id><sink_block_id>blocks_tag_debug_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>epy_block_0</source_block_id><sink_block_id>blocks_tagged_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>epy_block_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
